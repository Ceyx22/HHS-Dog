Commit message: ros time error

File: src/unitree/urdf/go1.urdf (robot description, URDF)
Before this commit: robot go1_description, 23 links, 22 joints
Links:
- removed link world
Joints:
- removed joint 
